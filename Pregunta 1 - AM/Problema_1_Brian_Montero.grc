options:
  parameters:
    author: Brian Montero
    generate_options: qt_gui
    id: Problema_1_Brian_Montero
    output_language: python
    title: Problema_1_Brian_Montero
  states: {}

blocks:
- name: choose
  id: variable_qtgui_chooser
  parameters:
    label: choose
    label0: Pedro
    label1: Discurso Sam
    label2: Un violinista en tu tejado
    label3: Discruso 300
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
  states: {}
- name: modulacion
  id: variable_qtgui_range
  parameters:
    label: modulacion
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.02'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: volumen
  id: variable_qtgui_range
  parameters:
    label: volumen
    start: '0.1'
    step: '0.1'
    stop: '1.5'
    value: '0.1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 7e3
    low_cutoff_freq: 3e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 11e3
    low_cutoff_freq: 7e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 17e3
    low_cutoff_freq: 13e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 22e3
    low_cutoff_freq: 18e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volumen
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: choose
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: choose
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\Universidad\2024-1\LABCOM\Certamen2\prueba_audio_1
    repeat: 'True'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\r\nfrom gnuradio import gr\r\n\r\nclass am_demod(gr.sync_block):\r\n    def __init__(self, mod_index=1.0):\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name=\"AM Demod\",\r\n            in_sig=[np.float32],\r\n            out_sig=[np.float32]\r\n        )\r\n        self.mod_index = mod_index\r\n\r\n    def work(self, input_items, output_items):\r\n        in0 = input_items[0]\r\n        out = output_items[0]\r\n\r\n        # AM demodulation: absolute value of the signal divided by the modulation index\r\n        out[:] = np.abs(in0) / self.mod_index\r\n\r\n        return len(output_items[0])\r\n"
    mod_index: modulacion
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\r\nfrom gnuradio import gr\r\n\r\nclass am_demod(gr.sync_block):\r\n    def __init__(self, mod_index=1.0):\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name=\"AM Demod\",\r\n            in_sig=[np.float32],\r\n            out_sig=[np.float32]\r\n        )\r\n        self.mod_index = mod_index\r\n\r\n    def work(self, input_items, output_items):\r\n        in0 = input_items[0]\r\n        out = output_items[0]\r\n\r\n        # AM demodulation: absolute value of the signal divided by the modulation index\r\n        out[:] = np.abs(in0) / self.mod_index\r\n\r\n        return len(output_items[0])\r\n"
    mod_index: modulacion
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\r\nfrom gnuradio import gr\r\n\r\nclass am_demod(gr.sync_block):\r\n    def __init__(self, mod_index=1.0):\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name=\"AM Demod\",\r\n            in_sig=[np.float32],\r\n            out_sig=[np.float32]\r\n        )\r\n        self.mod_index = mod_index\r\n\r\n    def work(self, input_items, output_items):\r\n        in0 = input_items[0]\r\n        out = output_items[0]\r\n\r\n        # AM demodulation: absolute value of the signal divided by the modulation index\r\n        out[:] = np.abs(in0) / self.mod_index\r\n\r\n        return len(output_items[0])\r\n"
    mod_index: modulacion
  states: {}
- name: epy_block_0_0_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\r\nfrom gnuradio import gr\r\n\r\nclass am_demod(gr.sync_block):\r\n    def __init__(self, mod_index=1.0):\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name=\"AM Demod\",\r\n            in_sig=[np.float32],\r\n            out_sig=[np.float32]\r\n        )\r\n        self.mod_index = mod_index\r\n\r\n    def work(self, input_items, output_items):\r\n        in0 = input_items[0]\r\n        out = output_items[0]\r\n\r\n        # AM demodulation: absolute value of the signal divided by the modulation index\r\n        out[:] = np.abs(in0) / self.mod_index\r\n\r\n        return len(output_items[0])\r\n"
    mod_index: modulacion
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '30'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '30'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: high_pass_filter_0_1
  id: high_pass_filter
  parameters:
    cutoff_freq: '30'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: high_pass_filter_0_2
  id: high_pass_filter
  parameters:
    cutoff_freq: '30'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '128'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}

connections:
- [band_pass_filter_0, '0', epy_block_0_0, '0']
- [band_pass_filter_0_0, '0', epy_block_0_0_0, '0']
- [band_pass_filter_0_0_0, '0', epy_block_0_0_1, '0']
- [band_pass_filter_0_1, '0', epy_block_0_0_2, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_selector_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0_1, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [epy_block_0_0, '0', low_pass_filter_0_0, '0']
- [epy_block_0_0_0, '0', low_pass_filter_0, '0']
- [epy_block_0_0_1, '0', low_pass_filter_0_1, '0']
- [epy_block_0_0_2, '0', low_pass_filter_0_2, '0']
- [high_pass_filter_0, '0', blocks_selector_0, '1']
- [high_pass_filter_0, '0', blocks_selector_0_0, '1']
- [high_pass_filter_0_0, '0', blocks_selector_0, '0']
- [high_pass_filter_0_0, '0', blocks_selector_0_0, '0']
- [high_pass_filter_0_1, '0', blocks_selector_0, '2']
- [high_pass_filter_0_1, '0', blocks_selector_0_0, '2']
- [high_pass_filter_0_2, '0', blocks_selector_0, '3']
- [high_pass_filter_0_2, '0', blocks_selector_0_0, '3']
- [low_pass_filter_0, '0', high_pass_filter_0, '0']
- [low_pass_filter_0_0, '0', high_pass_filter_0_0, '0']
- [low_pass_filter_0_1, '0', high_pass_filter_0_1, '0']
- [low_pass_filter_0_2, '0', high_pass_filter_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
