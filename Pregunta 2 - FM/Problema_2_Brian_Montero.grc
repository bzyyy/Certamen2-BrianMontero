options:
  parameters:
    author: Brian Montero
    generate_options: qt_gui
    id: Problema_2_Brian_Montero
    output_language: python
    title: Problema_2_Brian_Montero
  states: {}

blocks:
- name: choose
  id: variable_qtgui_chooser
  parameters:
    label: choose
    label0: Discurso Sam
    label1: Cancion X
    label2: Cancion Y
    label3: Discurso 300
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
  states: {}
- name: modulacion
  id: variable_qtgui_range
  parameters:
    label: modulacion
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.02'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: volumen
  id: variable_qtgui_range
  parameters:
    label: volumen
    start: '0.1'
    step: '0.1'
    stop: '1.5'
    value: '0.1'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_1
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_1_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: analog_simple_squelch_cc_0_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: analog_simple_squelch_cc_0_1_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '7000'
    low_cutoff_freq: '3000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 11e3
    low_cutoff_freq: 7e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 22e3
    low_cutoff_freq: 18e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '12000'
    low_cutoff_freq: '8000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_2_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '18000'
    low_cutoff_freq: '13000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_2_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '22000'
    low_cutoff_freq: '18000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\Universidad\2024-1\LABCOM\Certamen2\Certamen 2 - GNU\Certamen2-BrianMontero\Pregunta 2 - FM\Salida_4_Senales_FM.txt
    type: complex
  states: {}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volumen
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '1'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: choose
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: choose
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\Universidad\2024-1\LABCOM\Certamen2\Certamen 2 - GNU\Certamen2-BrianMontero\Pregunta 2 - FM\prueba_audio_1
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: D:\Universidad\2024-1\LABCOM\Certamen2\Certamen 2 - GNU\Certamen2-BrianMontero\Pregunta 2 - FM\audioX.mp3
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: D:\Universidad\2024-1\LABCOM\Certamen2\Certamen 2 - GNU\Certamen2-BrianMontero\Pregunta 2 - FM\audioY.mp3
    repeat: 'True'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\r\nfrom gnuradio import gr\r\n\r\nclass am_demod(gr.sync_block):\r\n    def __init__(self, mod_index=1.0):\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name=\"AM Demod\",\r\n            in_sig=[np.float32],\r\n            out_sig=[np.float32]\r\n        )\r\n        self.mod_index = mod_index\r\n\r\n    def work(self, input_items, output_items):\r\n        in0 = input_items[0]\r\n        out = output_items[0]\r\n\r\n        # AM demodulation: absolute value of the signal divided by the modulation index\r\n        out[:] = np.abs(in0) / self.mod_index\r\n\r\n        return len(output_items[0])\r\n"
    mod_index: modulacion
  states: {}
- name: epy_block_0_0_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\r\nfrom gnuradio import gr\r\n\r\nclass am_demod(gr.sync_block):\r\n    def __init__(self, mod_index=1.0):\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name=\"AM Demod\",\r\n            in_sig=[np.float32],\r\n            out_sig=[np.float32]\r\n        )\r\n        self.mod_index = mod_index\r\n\r\n    def work(self, input_items, output_items):\r\n        in0 = input_items[0]\r\n        out = output_items[0]\r\n\r\n        # AM demodulation: absolute value of the signal divided by the modulation index\r\n        out[:] = np.abs(in0) / self.mod_index\r\n\r\n        return len(output_items[0])\r\n"
    mod_index: modulacion
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class FM_Modulator_Block(gr.sync_block):
          def __init__(self, fc1=5e3, fc2=10e3, fc3=15e3, fc4=20e3, sample_rate=48e3, kf=1.0):
              """
              Parameteros:
              - fc1, fc2, fc3, fc4: Frecuencias de portadora para cada una de las 4 señales.
              """
              gr.sync_block.__init__(
                  self,
                  name='FM Modulator Block',   # Nombre que se mostrará en GRC
                  in_sig=[np.float32, np.float32, np.float32, np.float32],  # 4 entradas de señales de audio
                  out_sig=[np.complex64]  # Salida de la señal combinada modulada en frecuencia
              )
              self.fc = [fc1, fc2, fc3, fc4]
              self.sample_rate = sample_rate
              self.kf = kf

          def work(self, input_items, output_items):
              """
              El trabajo del bloque: modula cada señal en frecuencia y suma las señales moduladas.
              """
              audio_signals = np.array(input_items)  # Convertir las señales de entrada en un array de numpy
              output = np.zeros(len(audio_signals[0]), dtype=np.complex64)  # Inicializar la salida

              t = np.arange(len(audio_signals[0])) / self.sample_rate  # Calcular el vector de tiempo

              for i in range(4):
                  audio_signal = audio_signals[i]  # Obtener la señal de audio
                  carrier_freq = self.fc[i]  # Obtener la frecuencia de la portadora
                  # Modulación en frecuencia
                  modulated_signal = np.exp(1j * (2 * np.pi * carrier_freq * t + self.kf * np.cumsum(audio_signal) / self.sample_rate))
                  output += modulated_signal  # Sumar la señal modulada

              output_items[0][:] = output  # Escribir el resultado en el buffer de salida
              return len(output_items[0])  # Retornar el número de muestras procesadas
    fc1: '5000'
    fc2: '10000'
    fc3: '15000'
    fc4: '20000'
    kf: '1'
    sample_rate: samp_rate
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '30'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: high_pass_filter_0_2
  id: high_pass_filter
  parameters:
    cutoff_freq: '30'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: FM
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: FM
  states: {}

connections:
- [analog_nbfm_rx_0, '0', low_pass_filter_0_2_0_0, '0']
- [analog_nbfm_rx_0_0, '0', low_pass_filter_0_2_0_0_0, '0']
- [analog_nbfm_rx_0_1, '0', low_pass_filter_0_2_0_0_1, '0']
- [analog_nbfm_rx_0_1_0, '0', low_pass_filter_0_2_0_0_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_nbfm_rx_0_0, '0']
- [analog_simple_squelch_cc_0_1, '0', analog_nbfm_rx_0_1, '0']
- [analog_simple_squelch_cc_0_1_0, '0', analog_nbfm_rx_0_1_0, '0']
- [band_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [band_pass_filter_0_0, '0', epy_block_0_0_0, '0']
- [band_pass_filter_0_1, '0', epy_block_0_0_2, '0']
- [band_pass_filter_0_2, '0', analog_simple_squelch_cc_0_0, '0']
- [band_pass_filter_0_2_0, '0', analog_simple_squelch_cc_0_1, '0']
- [band_pass_filter_0_2_0_0, '0', analog_simple_squelch_cc_0_1_0, '0']
- [blocks_head_1, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_repeat_0, '0', blocks_head_1, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_selector_0_0, '0', qtgui_sink_x_0_1_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0_1, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle2_0_0, '0', epy_block_1, '1']
- [blocks_throttle2_0_0_0, '0', epy_block_1, '2']
- [blocks_throttle2_1, '0', band_pass_filter_0, '0']
- [blocks_throttle2_1, '0', band_pass_filter_0_2, '0']
- [blocks_throttle2_1, '0', band_pass_filter_0_2_0, '0']
- [blocks_throttle2_1, '0', band_pass_filter_0_2_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_wavfile_source_0_0_0, '0', blocks_throttle2_0_0_0, '0']
- [epy_block_0_0_0, '0', low_pass_filter_0, '0']
- [epy_block_0_0_2, '0', low_pass_filter_0_2, '0']
- [epy_block_1, '0', blocks_repeat_0, '0']
- [epy_block_1, '0', qtgui_freq_sink_x_0_1, '0']
- [epy_block_1, '0', virtual_sink_0, '0']
- [high_pass_filter_0, '0', epy_block_1, '0']
- [high_pass_filter_0_2, '0', epy_block_1, '3']
- [low_pass_filter_0, '0', high_pass_filter_0, '0']
- [low_pass_filter_0_2, '0', high_pass_filter_0_2, '0']
- [low_pass_filter_0_2_0_0, '0', blocks_selector_0, '0']
- [low_pass_filter_0_2_0_0, '0', blocks_selector_0_0, '0']
- [low_pass_filter_0_2_0_0_0, '0', blocks_selector_0, '1']
- [low_pass_filter_0_2_0_0_0, '0', blocks_selector_0_0, '1']
- [low_pass_filter_0_2_0_0_0_0, '0', blocks_selector_0, '3']
- [low_pass_filter_0_2_0_0_0_0, '0', blocks_selector_0_0, '3']
- [low_pass_filter_0_2_0_0_1, '0', blocks_selector_0, '2']
- [low_pass_filter_0_2_0_0_1, '0', blocks_selector_0_0, '2']
- [virtual_source_0_0, '0', blocks_throttle2_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
